# IAR project AIRBoosterStack.ewp, settings and files
configuration EZ430_CC1101 (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430fn.h
  General.OGChipSelectMenu: MSP430F2274 MSP430F2274
  General.GStackSize2: 512
  General.GHeapSize2: 80
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: __BOARD_EZ430_SERIES; __RADIO_CCXXX_CC1101
  ICC430.newCCIncludePaths: ; Application\Settings
  ICC430.CCOptLevel: 0
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  A430.AUserIncludes: ; Application\Settings
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F2274.xcl
  XLINK.XlinkStackSize: 1
configuration EZ430_CC110L (MSP430, debug)
  as the first configuration, except:
  General.GStackSize2: 180
  ICC430.CCDefines: __BOARD_EZ430_SERIES; __RADIO_CCXXX_CC110L
configuration EZ430_CC2500 (MSP430, debug)
  as the first configuration, except:
  ICC430.CCDefines: __BOARD_EZ430_SERIES; __RADIO_CCXXX_CC2500
configuration LaunchPad_CC1101 (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 180
  ICC430.CCDefines: __BOARD_LAUNCHPAD_SERIES; __BOARD_AIRBOOSTERPACKLITE_SERIES; __RADIO_CCXXX_CC1101
  ICC430.CCOptLevel: 2
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
configuration LaunchPad_CC110L (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 180
  ICC430.CCDefines: __BOARD_LAUNCHPAD_SERIES; __BOARD_AIRBOOSTERPACKLITE_SERIES; __RADIO_CCXXX_CC110L
  ICC430.CCOptLevel: 2
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
configuration LaunchPad_CC2500 (MSP430, debug)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 180
  ICC430.CCDefines: __BOARD_LAUNCHPAD_SERIES; __BOARD_AIRBOOSTERPACKLITE_SERIES; __RADIO_CCXXX_CC2500
  ICC430.CCOptLevel: 2
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
configuration LaunchPad_CC110L_Release (MSP430)
  as the first configuration, except:
  General.OGChipSelectMenu: MSP430G2553 MSP430G2553
  General.GStackSize2: 180
  ICC430.CCDefines: NDEBUG; __BOARD_LAUNCHPAD_SERIES; __BOARD_AIRBOOSTERPACKLITE_SERIES; __RADIO_CCXXX_CC110L
  ICC430.CCOptLevel: 2
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430G2553.xcl
  group Application
    Application/: Application.c application.h Callback.c CommandInterface.c CommandInterface.h Definitions.h main.c Protocol.c Protocol.h RadioOperation.c RadioOperation.h
  group Application/Settings
    Application/Settings/: Settings.h
  group Application/Settings/MCU
    Application/Settings/: MSP430F2274Settings.h MSP430G2553Settings.h
  group Application/Settings/Radio
    Application/Settings/: CC1101Settings.h CC110LSettings.h CC2500Settings.h
  group Framework/Board
    Framework/Board/: BoardDefinition.h
  group Framework/Board/EZ430
    Framework/Board/EZ430/: EZ430.h
  group Framework/Board/LaunchPad
    Framework/Board/LaunchPad/: LaunchPad.h
  group Framework/Configuration
    Framework/Configuration/: Config.h
  group Framework/FPI
    Framework/FPI/: FPI.c FPI.h
  group Framework/FPI/Devices/COMPort
    Framework/FPI/Devices/COMPort/: COMPortInterface.c
  group Framework/FPI/Devices/LED
    Framework/FPI/Devices/LED/: LEDInterface.c
  group Framework/FPI/Devices/Radio
    Framework/FPI/Devices/Radio/: RadioInterface.c RadioInterface.h
  group Framework/FPI/Devices/Radio/CCXXX
    Framework/FPI/Devices/Radio/CCXXX/: CCXXXInterface.c CCXXXInterface.h
  group Framework/FPI/Devices/Radio/CCXXX/Configuration
    Framework/FPI/Devices/Radio/CCXXX/Configuration/: CCXXXConfig.h
  group Framework/FPI/Devices/Radio/CCXXX/Interface
    Framework/FPI/Devices/Radio/CCXXX/Interface/: CC1101Interface.c CC1101Interface.h
  group Framework/FPI/Devices/Radio/CCXXX/Model
    Framework/FPI/Devices/Radio/CCXXX/Model/: CC1101.h CC110L.h CC2500.h
  group Framework/MCU
    Framework/MCU/: MCUInterface.c MCUInterface.h
  group Framework/MCU/MSP430
    Framework/MCU/MSP430/: Analog.c Analog.h Architecture.c Architecture.h Communication.c Communication.h DataConverter.c DataConverter.h GPIO.c GPIO.h LCD.c LCD.h SpecialModule.c SpecialModule.h Timer.c Timer.h
  group Framework/MCU/MSP430/Configuration
    Framework/MCU/MSP430/Configuration/: MSP430Config.h
  group Framework/MCU/MSP430/Model
    Framework/MCU/MSP430/Model/: F2274.h G2553.h
  group Framework/MCU/MSP430/Peripherals/Architecture
    Framework/MCU/MSP430/Peripherals/Architecture/: BasicClockSystemPlus.c BasicClockSystemPlus.h Flash.h
  group Framework/MCU/MSP430/Peripherals/Communication
    Framework/MCU/MSP430/Peripherals/Communication/: USCI.c USCI.h
  group Framework/MCU/MSP430/Peripherals/DataConverter
    Framework/MCU/MSP430/Peripherals/DataConverter/: ADC10.c ADC10.h
  group Framework/MCU/MSP430/Peripherals/GPIO
    Framework/MCU/MSP430/Peripherals/GPIO/: DigitalIO.c DigitalIO.h
  group Framework/MCU/MSP430/Peripherals/Timer
    Framework/MCU/MSP430/Peripherals/Timer/: TimerA.c TimerA.h WatchdogTimerPlus.c WatchdogTimerPlus.h
