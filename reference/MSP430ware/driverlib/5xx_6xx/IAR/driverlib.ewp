# IAR project driverlib.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xlfn.h
  General.OGChipSelectMenu: MSP430F5438A MSP430F5438A
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\..\..\; ..\..\..\deprecated\IAR\
  ICC430.CCOptLevel: 3
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5438A.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ../: adc10.c adc10.h adc12.c adc12.h bat.c bat.h compb.c compb.h crc.c crc.h dac12.c dac12.h debug.h dma.c dma.h flash.c flash.h gpio.c gpio.h i2c.c i2c.h ldoPwr.c ldoPwr.h mpy32.c mpy32.h pmap.c pmap.h pmm.c pmm.h ramcontroller.c ramcontroller.h ref.c ref.h rtc.c rtc.h sfr_sys.c sfr_sys.h spi.c spi.h timer.c timer.h tlv.c tlv.h uart.c uart.h uart_baudrate.c uart_baudrate.h ucs.c ucs.h wdt.c wdt.h
