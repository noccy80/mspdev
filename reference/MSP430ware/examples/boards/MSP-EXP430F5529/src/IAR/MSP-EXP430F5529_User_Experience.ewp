# IAR project MSP-EXP430F5529_User_Experience.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 1024
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: ..\; ..\CTS; ..\F5xx_F6xx_Core_Lib; ..\FatFs; ..\MSP-EXP430F5529_HAL; ..\USB; ..\USB\USB_API; ..\USB\USB_API\USB_CDC_API; ..\USB\USB_API\USB_Common; ..\USB\USB_API\USB_HID_API; ..\USB\USB_API\USB_MSC_API; ..\USB\USB_config; ..\USB\USB_User; ..\UserExperienceDemo; ..\UserExperienceDemo\Puzzle
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5529.xcl
  XLINK.XlinkStackSize: 1
configuration Release (MSP430)
  as the first configuration, except:
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: low_level_init.c
    ../: readme.txt UserExperience.c
  group CTS
    ../CTS/: CTS_HAL.c CTS_HAL.h CTS_Layer.c CTS_Layer.h structure.c structure.h
  group F5xx_F6xx_Core_Lib
    ../F5xx_F6xx_Core_Lib/: HAL_FLASH.c HAL_FLASH.h hal_macros.h HAL_PMAP.c HAL_PMAP.h HAL_PMM.c HAL_PMM.h HAL_TLV.c HAL_TLV.h HAL_UCS.c HAL_UCS.h
  group FatFs
    ../FatFs/: 00readme.txt diskio.h ff.c ff.h ffconf.h mmc.c
  group FatFs/option
    ../FatFs/option/: cc932.c cc936.c cc949.c cc950.c ccsbcs.c syscall.c
  group MSP-EXP430F5529_HAL
    ../MSP-EXP430F5529_HAL/: HAL_AppUart.c HAL_AppUart.h HAL_Board.c HAL_Board.h HAL_Buttons.c HAL_Buttons.h HAL_Cma3000.c HAL_Cma3000.h HAL_Dogs102x6.c HAL_Dogs102x6.h HAL_Menu.c HAL_Menu.h HAL_SDCard.c HAL_SDCard.h HAL_Wheel.c HAL_Wheel.h
  group USB/USB_API/USB_CDC_API
    ../USB/USB_API/USB_CDC_API/: UsbCdc.c UsbCdc.h
  group USB/USB_API/USB_Common
    ../USB/USB_API/USB_Common/: defMSP430USB.h device.h dma.c types.h usb.c usb.h UsbIsr.h
  group USB/USB_API/USB_HID_API
    ../USB/USB_API/USB_HID_API/: UsbHid.c UsbHid.h UsbHidReportHandler.c UsbHidReportHandler.h UsbHidReq.c UsbHidReq.h
  group USB/USB_API/USB_MSC_API
    ../USB/USB_API/USB_MSC_API/: UsbMsc.h UsbMscReq.c UsbMscReq.h UsbMscScsi.c UsbMscScsi.h UsbMscStateMachine.c UsbMscStateMachine.h
  group USB/USB_config
    ../USB/USB_config/: descriptors.c descriptors.h UsbIsr.c
  group USB/USB_User
    ../USB/USB_User/: usb_eventHandling.c usbConstructs.c usbConstructs.h UsbMscUser.c UsbMscUser.h
  group UserExperienceDemo
    ../UserExperienceDemo/: 5xx_ACTIVE_test.h 5xx_ACTIVE_test.s43 Clock.c Clock.h Demo_Cube.c Demo_Cube.h DemoApps.c DemoApps.h EchoUsb.c EchoUsb.h LaunchpadDef.h LPM.c LPM.h MassStorage.c MassStorage.h MassStorageCommon.c MassStorageCommon.h MenuGames.c MenuGames.h Mouse.c Mouse.h PMM.c PMM.h PowerTest.c PowerTest.h Random.c Random.h SDCard.c SDCard.h Settings.c Settings.h
  group UserExperienceDemo/Puzzle
    ../UserExperienceDemo/Puzzle/: fsm.c fsm.h fsm_transition.c fsm_transition.h Puzzle.c Puzzle.h
