<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\MSP-EXP430F5529_User_Experience.ewp</path>
  </project>
  <batchBuild/>
</workspace>


