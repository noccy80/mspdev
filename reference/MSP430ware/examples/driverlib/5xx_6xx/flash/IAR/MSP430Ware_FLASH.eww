<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\..\..\flash\IAR\FLASH_example1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\flash\IAR\FLASH_example2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\..\..\flash\IAR\FLASH_example3.ewp</path>
  </project>
  <batchBuild/>
</workspace>


