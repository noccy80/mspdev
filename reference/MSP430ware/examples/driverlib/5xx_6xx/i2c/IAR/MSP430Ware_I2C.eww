<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\I2C_master_rx_multi_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\I2C_master_rx_single_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\I2C_master_tx_multi_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\I2C_master_tx_single_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\I2C_slave_rx_multi_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\I2C_slave_rx_single_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\I2C_slave_tx_multi_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\I2C_slave_tx_single_int.ewp</path>
  </project>
  <batchBuild/>
</workspace>


