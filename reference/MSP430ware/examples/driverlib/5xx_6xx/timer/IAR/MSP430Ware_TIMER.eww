<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\TIMER_continousModeWithCCR0Interrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TIMER_continousModeWithTAIEInterrupt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TIMER_PWM_Example1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TIMER_PWM_Example2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TIMER_PWM_Example3.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TIMER_upDownModeOperation.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TIMER_upModeOperation.ewp</path>
  </project>
  <batchBuild/>
</workspace>


