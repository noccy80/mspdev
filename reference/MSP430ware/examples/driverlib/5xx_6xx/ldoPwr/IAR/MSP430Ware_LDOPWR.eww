<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\LDOPWR_example1.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\LDOPWR_example2.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\LDOPWR_example3.ewp</path>
  </project>
  <batchBuild/>
</workspace>


