<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\M1_Example\M1_Example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\M2_Example\M2_Example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\M3_Example\M3_Example.ewp</path>
  </project>
  <batchBuild/>
</workspace>


