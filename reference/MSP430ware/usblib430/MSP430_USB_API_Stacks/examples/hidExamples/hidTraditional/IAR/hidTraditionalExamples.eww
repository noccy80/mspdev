<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\mouse_H7_Example\mouse_H7_Example.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\keyboard_H8_Example\keyboard_H8_Example.ewp</path>
  </project>  
  <batchBuild/>
</workspace>


