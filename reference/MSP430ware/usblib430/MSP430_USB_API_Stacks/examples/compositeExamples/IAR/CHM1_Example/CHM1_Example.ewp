# IAR project CHM1_Example.ewp, settings and files
configuration Debug (MSP430, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl430xsfn.h
  General.OGChipSelectMenu: MSP430F5529 MSP430F5529
  General.GStackSize2: 160
  General.GHeapSize2: 160
  General.RadioHeapSizeType: 0
  ICC430.newCCIncludePaths: $PROJ_DIR$; USB_config; F5xx_F6xx_Core_Lib
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\CONFIG\lnk430F5529.xcl
  XLINK.XlinkStackSize: 1
  XLINK.XExtraOptions: -P(CONST)MYDRIVE=0xD000-0xF000
configuration Release (MSP430)
  as the first configuration, except:
  General.RTConfigPath: xxx.h
  ICC430.CCDefines: NDEBUG
  ICC430.CCOptLevel: 3
  XLINK.XclFile: lnk0t.xcl
  group (top)
    ./: main.c usbEventHandling.c mscFse.c LUN0_data.c LUN0_data.h usbConstructs.c usbConstructs.h
  group F5xx_F6xx_Core_Lib
    F5xx_F6xx_Core_Lib/: HAL_FLASH.c HAL_FLASH.h HAL_MACROS.h HAL_PMAP.c HAL_PMAP.h HAL_PMM.c HAL_PMM.h HAL_TLV.c HAL_TLV.h HAL_UCS.c HAL_UCS.h
  group USB_API/USB_CDC_API
    USB_API/USB_CDC_API/: UsbCdc.c UsbCdc.h
  group USB_API/USB_Common
    USB_API/USB_Common/: defMSP430USB.h device.h dma.c types.h usb.c usb.h UsbIsr.h
  group USB_API/USB_HID_API
    USB_API/USB_HID_API/: UsbHid.c UsbHid.h UsbHidReportHandler.c UsbHidReportHandler.h UsbHidReq.c UsbHidReq.h
  group USB_API/USB_MSC_API
    USB_API/USB_MSC_API/: UsbMsc.h UsbMscReq.c UsbMscReq.h UsbMscScsi.c UsbMscScsi.h UsbMscStateMachine.c UsbMscStateMachine.h
  group USB_config
    USB_config/: descriptors.c descriptors.h UsbIsr.c
  group FatFs
    FatFs/: diskio.h ff.c ff.h ffconf.h HAL_SDCard.c HAL_SDCard.h mmc.c mmc.h
